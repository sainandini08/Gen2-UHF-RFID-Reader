options:
  parameters:
    generate_options: qt_gui
    id: reader
    output_language: python
    title: EE4002D
  states: {}

blocks:
- name: adc_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: ampl
  id: variable
  parameters:
    value: '0.5'
  states: {}
- name: dac_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: decim
  id: variable
  parameters:
    value: '4'
  states: {}
- name: freq
  id: variable
  parameters:
    value: 900e6
  states: {}
- name: num_taps
  id: variable
  parameters:
    value: '[1] * 25'
  states: {}
- name: path_to_data
  id: variable
  parameters:
    value: '"/home/sakeru/Desktop/fyp/Gen2-UHF-RFID-Reader/gr-rfid/misc/data/"'
  states: {}
- name: rx_bw
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: rx_gain
  id: variable
  parameters:
    value: '40'
  states: {}
- name: tx_bw
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: tx_gain
  id: variable
  parameters:
    value: '70'
  states: {}
- name: zmq_addr
  id: variable
  parameters:
    value: '"tcp://127.0.0.1:5555"'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: path_to_data+"source"
    type: complex
  states: {state: disabled}
- name: blocks_file_sink_2
  id: blocks_file_sink
  parameters:
    file: path_to_data+"matched_filter"
    type: complex
  states: {state: disabled}
- name: blocks_file_sink_3
  id: blocks_file_sink
  parameters:
    file: path_to_data+"gate"
    type: complex
  states: {state: disabled}
- name: blocks_file_sink_4
  id: blocks_file_sink
  parameters:
    file: path_to_data+"reader"
    type: float
  states: {state: disabled}
- name: blocks_file_sink_6
  id: blocks_file_sink
  parameters:
    file: path_to_data+"to_complex"
    type: complex
  states: {state: disabled}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/sakeru/Desktop/fyp/Gen2-UHF-RFID-Reader/gr-rfid/misc/data/source
    repeat: 'False'
    type: complex
  states: {state: disabled}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_float_to_uchar_0
  id: blocks_float_to_uchar
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: ampl
    type: float
  states: {state: bypassed}
- name: blocks_throttle_1
  id: blocks_throttle
  parameters:
    samples_per_second: adc_rate
    type: complex
  states: {state: disabled}
- name: fir_filter_xxx_0
  id: fir_filter_xxx
  parameters:
    decim: decim
    taps: num_taps
    type: ccc
  states: {state: disabled}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: decim
    fbw: '0.4'
    interp: '1'
    taps: ''
    type: ccc
  states: {}
- name: rfid_gate_0
  id: rfid_gate
  parameters:
    sample_rate: int(adc_rate/decim)
  states: {}
- name: rfid_reader_0
  id: rfid_reader
  parameters:
    dac_rate: int(dac_rate)
    sample_rate: int(adc_rate/decim)
  states: {}
- name: rfid_tag_decoder_0
  id: rfid_tag_decoder
  parameters:
    sample_rate: int(adc_rate/decim)
  states: {}
- name: uhd_usrp_sink_2
  id: uhd_usrp_sink
  parameters:
    ant0: TX/RX
    bw0: ''
    center_freq0: freq+200e3
    gain0: tx_gain
    len_tag_name: ''
    norm_gain0: 'False'
    samp_rate: dac_rate
    sync: pc_clock
    type: fc32
  states: {}
- name: uhd_usrp_source_1
  id: uhd_usrp_source
  parameters:
    ant0: RX2
    bw0: rx_bw
    center_freq0: freq
    dc_offs_enb0: '""'
    gain0: rx_gain
    iq_imbal_enb0: '""'
    norm_gain0: 'False'
    samp_rate: adc_rate
    sync: pc_clock
    type: fc32
  states: {}
- name: zeromq_pub_sink_0
  id: zeromq_pub_sink
  parameters:
    address: zmq_addr
    timeout: '100'
    type: byte
  states: {}

connections:
- [blocks_file_source_0, '0', blocks_throttle_1, '0']
- [blocks_float_to_complex_0, '0', blocks_file_sink_6, '0']
- [blocks_float_to_complex_0, '0', uhd_usrp_sink_2, '0']
- [blocks_float_to_uchar_0, '0', zeromq_pub_sink_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_float_to_complex_0, '0']
- [blocks_throttle_1, '0', fir_filter_xxx_0, '0']
- [blocks_throttle_1, '0', rational_resampler_xxx_0, '0']
- [fir_filter_xxx_0, '0', blocks_file_sink_2, '0']
- [fir_filter_xxx_0, '0', rfid_gate_0, '0']
- [rational_resampler_xxx_0, '0', blocks_file_sink_2, '0']
- [rational_resampler_xxx_0, '0', rfid_gate_0, '0']
- [rfid_gate_0, '0', blocks_file_sink_3, '0']
- [rfid_gate_0, '0', rfid_tag_decoder_0, '0']
- [rfid_reader_0, '0', blocks_file_sink_4, '0']
- [rfid_reader_0, '0', blocks_multiply_const_vxx_0, '0']
- [rfid_tag_decoder_0, '0', blocks_float_to_uchar_0, '0']
- [rfid_tag_decoder_0, '0', rfid_reader_0, '0']
- [uhd_usrp_source_1, '0', blocks_file_sink_0, '0']
- [uhd_usrp_source_1, '0', rational_resampler_xxx_0, '0']

metadata:
  file_format: 1
