options:
  parameters:
    generate_options: qt_gui
    id: reader
    output_language: python
    title: EE4002D
  states: {}

blocks:
- name: adc_rate
  id: variable
  parameters:
    value: 3.35*100e6/50
  states: {}
- name: ampl
  id: variable
  parameters:
    value: '0.8'
  states: {}
- name: dac_rate
  id: variable
  parameters:
    value: 3.35*1e6
  states: {}
- name: decim
  id: variable
  parameters:
    value: '5'
  states: {}
- name: freq
  id: variable
  parameters:
    value: 910e6
  states: {}
- name: num_taps
  id: variable
  parameters:
    value: '[1] * 83'
  states: {}
- name: path_to_data
  id: variable
  parameters:
    value: '"/home/sakeru/Desktop/fyp/Gen2-UHF-RFID-Reader/gr-rfid/misc/data/"'
  states: {}
- name: rx_gain
  id: variable
  parameters:
    value: '20'
  states: {}
- name: tx_gain
  id: variable
  parameters:
    value: '50'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: path_to_data+"source"
    type: complex
  states: {}
- name: blocks_file_sink_2
  id: blocks_file_sink
  parameters:
    file: path_to_data+"matched_filter"
    type: complex
  states: {}
- name: blocks_file_sink_2_0
  id: blocks_file_sink
  parameters:
    file: path_to_data+"decoder"
    type: complex
  states: {}
- name: blocks_file_sink_3
  id: blocks_file_sink
  parameters:
    file: path_to_data+"gate"
    type: complex
  states: {}
- name: blocks_file_sink_4
  id: blocks_file_sink
  parameters:
    file: path_to_data+"reader"
    type: float
  states: {}
- name: blocks_file_sink_6
  id: blocks_file_sink
  parameters:
    file: path_to_data+"to_complex"
    type: complex
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: ampl
    type: float
  states: {}
- name: fir_filter_xxx_0
  id: fir_filter_xxx
  parameters:
    decim: decim
    taps: num_taps
    type: ccc
  states: {}
- name: rfid_gate_0
  id: rfid_gate
  parameters:
    sample_rate: int(adc_rate/decim)
  states: {}
- name: rfid_reader_0
  id: rfid_reader
  parameters:
    dac_rate: int(dac_rate)
    sample_rate: int(adc_rate/decim)
  states: {}
- name: rfid_tag_decoder_0
  id: rfid_tag_decoder
  parameters:
    sample_rate: int(adc_rate/decim)
  states: {}
- name: uhd_usrp_sink_2
  id: uhd_usrp_sink
  parameters:
    ant0: BAND1
    center_freq0: freq
    dev_args: '"driver=lime,soapy=0"'
    gain0: tx_gain
    len_tag_name: ''
    norm_gain0: 'False'
    samp_rate: dac_rate
    sync: pc_clock
    type: fc32
  states: {}
- name: uhd_usrp_source_1
  id: uhd_usrp_source
  parameters:
    ant0: LNAL
    bw0: ''
    center_freq0: freq
    dc_offs_enb0: '""'
    dev_args: '"driver=lime,soapy=0"'
    gain0: rx_gain
    iq_imbal_enb0: '""'
    norm_gain0: 'False'
    samp_rate: adc_rate
    sync: pc_clock
    type: fc32
  states: {}

connections:
- [blocks_float_to_complex_0, '0', blocks_file_sink_6, '0']
- [blocks_float_to_complex_0, '0', uhd_usrp_sink_2, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_float_to_complex_0, '0']
- [fir_filter_xxx_0, '0', blocks_file_sink_2, '0']
- [fir_filter_xxx_0, '0', rfid_gate_0, '0']
- [rfid_gate_0, '0', blocks_file_sink_3, '0']
- [rfid_gate_0, '0', rfid_tag_decoder_0, '0']
- [rfid_reader_0, '0', blocks_file_sink_4, '0']
- [rfid_reader_0, '0', blocks_multiply_const_vxx_0, '0']
- [rfid_tag_decoder_0, '0', rfid_reader_0, '0']
- [rfid_tag_decoder_0, '1', blocks_file_sink_2_0, '0']
- [uhd_usrp_source_1, '0', blocks_file_sink_0, '0']
- [uhd_usrp_source_1, '0', fir_filter_xxx_0, '0']

metadata:
  file_format: 1
